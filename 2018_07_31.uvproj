# Keil uVision project 2018_07_31.uvproj, settings and files
target HT32 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HT32F1765 Holtek
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x00000000-0x0001FBFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: HT32 +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HT32_DRIVER, USE_HT32F1755_2755_DVB
  c include: ..\;..\..\..\..\library\HT32F175x_275x_Driver\inc;..\..\..\..\library\CMSIS\Include;..\..\..\..\library\Device\Holtek\HT32F175x_275x\Include;..\..\..\..\library\HT32_USBD_Library\inc;..\..\..\..\utilities
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1fc00
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group User
    ../: main.c ht32f175x_275x_it.c
  group Config
    ../: ht32f175x_275x_conf.h ht32f175x_275x_usbdconf.h
    ../MDK_ARM/: ht32_op.s
    ./: HT32F175x_275x_DebugSupport.ini
  group CMSIS
    ../: system_ht32f175x_275x.c
  group MDK-ARM
    ./: startup_ht32f175x_275x.s
  group USBD_Library
    ../../../../library/HT32_USBD_Library/src/: ht32_usbd_core.c
  group Library
    ../../../../library/HT32F175x_275x_Driver/src/: ht32_cm3_misc.c ht32f175x_275x_adc.c ht32f175x_275x_bftm.c ht32f175x_275x_ckcu.c ht32f175x_275x_cmp_op.c ht32f175x_275x_exti.c ht32f175x_275x_flash.c ht32f175x_275x_gpio.c ht32f175x_275x_gptm.c ht32f175x_275x_i2c.c ht32f175x_275x_mctm.c ht32f175x_275x_pdma.c ht32f175x_275x_pwrcu.c ht32f175x_275x_rstcu.c ht32f175x_275x_rtc.c ht32f175x_275x_sci.c ht32f175x_275x_spi.c ht32f175x_275x_usart.c ht32f175x_275x_usbd.c ht32f175x_275x_wdt.c ht32f275x_csif.c
  group Retarget
    ../../../../library/HT32F175x_275x_Driver/src/: ht32_retarget.c ht32_serial.c
  group Utilities
    ../../../../utilities/: ht32_board.c
    ../../../../utilities/common/: i2c_eeprom.c spi_flash.c spi_lcd.c
  group Doc
    ../: readme.txt
